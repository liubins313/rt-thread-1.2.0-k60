# Keil uVision project templete.uvproj, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK60D10 CHK60EVB2 DEBUG
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\CoreSupport;..\..\..\..\Libraries\startup\DeviceSupport;..\..\..\..\Libraries\drivers\K\inc;..\src\gui;..\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\finsh;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\dfs\filesystems\nfs;..\..\..\..\Libraries\utilities\emWin\Include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\drivers\include;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\bsp\Reven;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\init;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\Libraries\utilities\RT-Thread_1.2.0\components\net\lwip-1.4.1\src\include\netif
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group lib-startup
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
    ../../../../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group application
    ../src/: main.c rtconfig.h startup.c init_thread.c led_thread.c gui_thread.c sd_thread.c
    ../src/gui/: my_gui.c
  group lib-drivers
    ../../../../Libraries/drivers/K/src/: gpio.c uart.c pit.c cpuidy.c adc.c ftm.c i2c.c spi.c dma.c flexbus.c systick.c rtc.c enet.c common.c sd.c
  group lib-devices
    ../../../../Libraries/devices/src/: ili9320.c sram.c ksz8041.c
  group rtt-kernel
    ../../../../Libraries/utilities/RT-Thread_1.2.0/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group rtt-cortex-m4
    ../../../../Libraries/utilities/RT-Thread_1.2.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../Libraries/utilities/RT-Thread_1.2.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group rtt-finsh
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rtt-driver
    ../../../../Libraries/utilities/RT-Thread_1.2.0/bsp/Reven/: rtt_ili9320.c rtt_ksz8041.c rtt_rtc.c rtt_sd.c rtt_serial.c rtt_spi.c spi_flash_w25qxx.c touch_ads7843.c
  group rtt-devicer-struct
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/rtc/: alarm.c rrtc.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/serial/: serial.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group rtt-dfs
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/dfs/filesystems/nfs/: dfs_nfs.c mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c pmap.c rpc_prot.c xdr.c xdr_mem.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group emwin
    ../../../../Libraries/utilities/emWin/Lib/: GUI_CM3.lib
    ../../../../Libraries/utilities/emWin/: GUI_X.c GUIConf.c LCDConf.c
  group emwin-demo
    ../../../../Libraries/utilities/emWin/Sample/GUIDemo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group my_ui
    ../src/gui/: gui_clock.c gui_calendar.c gui_desktop.c gui_image.c gui_choosefile.c gui_notepad.c
  group kernel_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/kernel/: cpuusage.c event_simple.c heap_malloc.c heap_realloc.c mbox_send_wait.c mbox_simple.c memp_simple.c messageq_simple.c mutex.c mutex_simple.c sem.c semaphore_buffer_worker.c semaphore_dynamic.c semaphore_priority.c semaphore_producer_consumer.c semaphore_static.c tc_comm.c tc_sample.c thread_critical_var.c thread_delay.c thread_delete.c thread_detach.c thread_dynamic.c thread_dynamic_simple.c thread_priority.c thread_resume.c thread_same_priority.c thread_static.c thread_static_simple.c thread_suspend.c thread_yield.c timer_control.c timer_dynamic.c timer_static.c timer_stop_self.c timer_timeout.c
  group hw_test_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/test/: fs_test.c
  group fs_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/file/: listdir.c readspeed.c readwrite.c seekdir.c writespeed.c
  group app_gui_cmd
    ../src/gui/: gui_cmd_pic.c gui_cmd_choosefile.c gui_cmd_screenshot.c gui_cmd_demo.c
  group lwip-core
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-api
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-arch
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group lwip-netif
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../../../Libraries/utilities/RT-Thread_1.2.0/components/net/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group net_examples
    ../../../../Libraries/utilities/RT-Thread_1.2.0/examples/network/: dns_demo.c nfs.c tcpclient.c tcpsendpacket.c tcpserver.c udpclient.c udpserver.c
