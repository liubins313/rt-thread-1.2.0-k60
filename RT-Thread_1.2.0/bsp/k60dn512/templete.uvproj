# Keil uVision project templete.uvproj, settings and files
target mk60d10 (ARM-ADS)
  device: MK60DN512xxx10 Freescale Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(100000000) ELITTLE
  output: templete +hex
  AfterMake: fromelf --bin !L --output templete.bin
  c flags: Optim=4
  c define: MK60D10 CHK60EVB2 DEBUG
  c misc: --c99
  c include: .\Libraries\CMSIS\CoreSupport;.\Libraries\Kinetis_StdPeriph\inc;.\Libraries\CMSIS\DeviceSupport;.\drivers;..\..\include;..\..\components\finsh;..\..\components\dfs\include;..\..\components\dfs\filesystems\nfs;..\..\components\drivers\include;.\bsp_devices\inc;..\..\components\init;..\..\components\net\lwip-1.4.1\src;..\..\components\net\lwip-1.4.1\src\arch\include;..\..\components\net\lwip-1.4.1\src\include;..\..\components\net\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip-1.4.1\src\include\netif;..\k60dn512
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group lib-startup
    ./Libraries/CMSIS/DeviceSupport/: system_MK60D10.c
    ./Libraries/CMSIS/DeviceSupport/MDK-ARM/: startup_MK60D10.s
  group application
    ./applications/: main.c startup.c init_thread.c led_thread.c
  group lib-drivers
    ./Libraries/Kinetis_StdPeriph/src/: adc.c can.c common.c cpuidy.c dac.c dma.c enet.c flexbus.c ftm.c gpio.c i2c.c lptmr.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group lib-devices
    ./bsp_devices/src/: ili9320.c sram.c ksz8041.c
  group rtt-kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group rtt-cortex-m4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group rtt-finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rtt-driver
    ./drivers/: rtt_ili9320.c rtt_ksz8041.c rtt_rtc.c rtt_sd.c rtt_serial.c rtt_spi.c spi_flash_w25qxx.c touch_ads7843.c
  group rtt-devicer-struct
    ../../components/drivers/rtc/: alarm.c rrtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group rtt-dfs
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/nfs/: dfs_nfs.c mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c
    ../../components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c pmap.c rpc_prot.c xdr.c xdr_mem.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group hw_test_examples
    ../../examples/test/: fs_test.c
  group lwip-core
    ../../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-api
    ../../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-arch
    ../../components/net/lwip-1.4.1/src/arch/: sys_arch.c
  group lwip-netif
    ../../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ../../components/net/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group net_examples
    ../../examples/network/: dns_demo.c nfs.c tcpclient.c tcpsendpacket.c tcpserver.c udpclient.c udpserver.c
